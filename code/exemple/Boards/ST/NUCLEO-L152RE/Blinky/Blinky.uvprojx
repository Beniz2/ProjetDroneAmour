# Keil uVision project Blinky.uvprojx, settings and files
target STM32L152 Flash (ARM-ADS)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.3
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x14000) CPUTYPE("Cortex-M3") CLOCK(32000000) ELITTLE
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  group Source Files
    ./: Retarget.c Serial.c Blinky.c
  group Documentation
    ./: Abstract.txt
target STM32L152 RAM (ARM-ADS)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.3
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: VECT_TAB_SRAM
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x4000
software components: CMSIS:CORE 3.40.0, Board Support:Buttons 1.0.0, Board Support:LED 1.0.0, Device:Startup 1.0.0
